Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: LTR020.01 SIMPLE.ifc
Time: 2023-08-29T15:36:06
Author: Projekty i Wdrożenia
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (46)
Name | LTR020.02, Description | LTR020.02, ObjectType
 | LTR020.01.01 - Description: LTR020.01.01:1; ObjectType: SketchupComponentInstance
 | LTR020.01.02 - Description: LTR020.01.02:1; ObjectType: SketchupComponentInstance
 | LTR020.01.03 - Description: LTR020.01.03:1; ObjectType: SketchupComponentInstance
 | LTR020.01.04 - Description: LTR020.01.04:1; ObjectType: SketchupComponentInstance
38 x  | LTR020.02:1 | SketchupComponentInstance
 | LTR020.01.01.L - Description: LTR020.01.01.L:1; ObjectType: SketchupComponentInstance
 | LTR020.01.02.L - Description: LTR020.01.02.L:1; ObjectType: SketchupComponentInstance
 | LTR020.01.03.L - Description: LTR020.01.03.L:1; ObjectType: SketchupComponentInstance
 | LTR020.01.04.L - Description: LTR020.01.04.L:1; ObjectType: SketchupComponentInstance
